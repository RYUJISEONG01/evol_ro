Commit message: 변경

File: body.urdf (robot description, URDF)
Before this commit: robot robot, 3 links, 2 joints
Joints:
- joint Torso_LLeg: origin xyz=-0.5 0 1.5 rpy=0 0 0 -> xyz=-0.5 0 1 rpy=0 0 0
- joint Torso_RLeg: origin xyz=0.5 0 1.5 rpy=0 0 0 -> xyz=0.5 0 1 rpy=0 0 0
